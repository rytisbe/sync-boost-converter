# Keil uVision project sync_boost_converter.uvprojx, settings and files
target NUCLEO-G071RB (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G071RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00009000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: sync_boost_converter
  c flags: oTime=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group source
    ./: main.c
  group include
    ./: main.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.4.0
